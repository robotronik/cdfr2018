# Repository robotronik/cdfr2018 (continued)

## KiCad design Electronique/moteurs_brushless_elec/PCB/carte_moteurs.kicad_pcb (continued)

Board: 2 copper layers, 90.0 x 65.0 mm, 82 parts (32 on the bottom side), 70 nets.

Other parts of the board:
CAN: CONN_CAN; Molex_KK-6410-02_02x2.54mm_Straight
Encodeur 1: encoder_1; Molex_KK-6410-04_04x2.54mm_Straight
Encodeur 2: encoder_2; Molex_KK-6410-04_04x2.54mm_Straight
I2C: CONN_I2C; Molex_KK-6410-02_02x2.54mm_Straight
Libre: CONN_FREE; Molex_KK-6410-02_02x2.54mm_Straight
ST-Link: swdio; Pin_Header_Angled_1x04_Pitch2.54mm
Serial: CONN_SERIAL; Molex_KK-6410-02_02x2.54mm_Straight

Their connections:
+5V: Encodeur 1.1, Encodeur 2.1; also elsewhere on the board
/encodeurs/Ch_A1: Encodeur 1.2; also elsewhere on the board
/encodeurs/Ch_A2: Encodeur 2.2; also elsewhere on the board
/encodeurs/Ch_B1: Encodeur 1.4; also elsewhere on the board
/encodeurs/Ch_B2: Encodeur 2.4; also elsewhere on the board
/uC/I2C_SCL: I2C.2; also elsewhere on the board
/uC/I2C_SDA: I2C.1; also elsewhere on the board
/uC/RX: Serial.1; also elsewhere on the board
/uC/TX: Serial.2; also elsewhere on the board
/uC/nrst: ST-Link.2; also elsewhere on the board
/uC/swclk: ST-Link.3; also elsewhere on the board
/uC/swdio: ST-Link.4; also elsewhere on the board
GND: Encodeur 1.3, Encodeur 2.3, ST-Link.1; also elsewhere on the board
unnamed 58: Libre.1; also elsewhere on the board
unnamed 59: Libre.2; also elsewhere on the board
unnamed 60: CAN.1; also elsewhere on the board
unnamed 61: CAN.2; also elsewhere on the board

## KiCad design Electronique/driver_moteurs/driver-moteurs.kicad_pcb

Parts:
C1, C2, C3: C
D1: LED
JP1: JUMPER3
P1: CONN_ENCODER
P2: CONN_FREE_3
P3: CONN_I2C
P4: CONN_01X03
P6: CONN_SERIAL
P7: CONN_SWDIO
P8: CONN_CAN
R1, R3: R
R2: 470R
R11: 10kR
U1: stm32f303k8t6; LQFP-32_7x7mm_Pitch0.8mm
U2: MCP2562
U6: MC33926
U7: 74HC04
U8: 74LS126
Y1: Crystal

Connections:
+3V3: JP1.3, U1.1 (VDD), U1.5 (VDDA), U1.17 (VDDIO-2), U2.5 (VIO), U6.3 (VDD), U6.11 (SLEW); also elsewhere on the board
+5V: P1.1, R11.1, U2.3 (VDD), U7.14 (VCC), U8.14 (VCC); also elsewhere on the board
+9V: P4.2; also elsewhere on the board
/I2C_SCA: P3.1, U1.30 (PB7)
/I2C_SCL: P3.2, U1.29 (PB6)
/RX: P6.2, U1.9 (PA3), U2.1 (TXD)
/RX_Servo: U1.20 (PA10), U8.6 (O)
/TX: P6.1, U1.8 (PA2), U2.4 (RXD)
/TX_Servo: U1.19 (PA9), U8.2
/nrst: C3.1, P7.2, U1.4 (N-RST)
/swclk: P7.3, U1.24 (PA14)
/swdio: P7.4, U1.23 (PA13)
unnamed: C1.1, U1.2 (PF0), Y1.1
unnamed: C2.1, R1.2, Y1.2
unnamed: D1.2, R2.1
unnamed: JP1.2, U1.31 (BOOT0/PB8)
unnamed: P1.2, U1.7 (PA1)
unnamed: P1.4, U1.6 (PA0)
unnamed: P2.1, U1.28 (PB5)
unnamed: P2.2, U1.27 (PB4)
unnamed: P4.1, R11.2, U8.3, U8.5 (D)
unnamed 26: P2.3, U1.26 (PB3); also elsewhere on the board
unnamed: P8.1, R3.1, U2.7 (CANH)
unnamed: P8.2, R3.2, U2.6 (CANL)
unnamed: R1.1, U1.3 (PF1)
unnamed: R2.2, U1.25 (PA15)
unnamed: U1.10 (PA4), U6.12 (INV)
unnamed: U1.11 (PA5), U6.10 (EN)
unnamed: U1.12 (PA6), U6.9 (FB)
unnamed: U1.13 (PA7), U6.8 (~SF)
unnamed: U1.14 (PB0), U6.7 (~PWM~/D1)
unnamed: U1.15 (PB1), U6.6 (PWM/~D2)
unnamed: U1.21 (PA11), U6.5 (IN1)
unnamed: U1.22 (PA12), U6.4 (IN2)
unnamed: U7.2, U8.4 (E)
VDD: U6.1 (VIN); also elsewhere on the board

Parts:
C4, C8: CP; CP_Radial_D8.0mm_P3.50mm
C5, C6, C7, C9: C; C_1206_HandSoldering
D2, D6: D; D_SMA_Handsoldering
D3, D4, D5: LED; D_SMA-SMB_Universal_Handsoldering
F1, F2: F_Small; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
R4, R5, R8, R9: R; R_1206_HandSoldering
R6: 2kR; R_1206_HandSoldering
R7, R10: 470R; R_1206_HandSoldering
U3, U9: B_Plug_5mm; B plug 5mm
U4: LM317_SOT223; SOT-223-3Lead_TabPin2
U5: LM317_SOT223

Connections:
+3V3: C6.1, R5.1, R7.2, U4.2 (OUT); also elsewhere on the board
+5V: C7.1, R9.1, R10.2, U5.2 (OUT); also elsewhere on the board
+9V: C8.1, C9.1, D6.1 (K), F2.2; also elsewhere on the board
unnamed: D3.2 (A), R6.1
unnamed: D4.2 (A), R7.1
unnamed: D5.2 (A), R10.1
unnamed: F1.1, U3.1
unnamed: F2.1, U9.1
unnamed: R4.1, R5.2, U4.1 (ADJ)
unnamed: R8.1, R9.2, U5.1 (ADJ)
VDD: C4.1, C5.1, D2.1 (K), F1.2, R6.2, U4.3 (IN), U5.3 (IN); also elsewhere on the board

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
Board: 2 copper layers, 71.6 x 62.7 mm, 51 parts (4 on the bottom side), 45 nets.

Other parts of the board:
P5: CONN_FC; Molex_KK-6410-02_02x2.54mm_Straight
U10, U11, U12, U13: Trou-3

Their connections:
+3V3: P5.2; also elsewhere on the board
unnamed 26: P5.1; also elsewhere on the board

## KiCad design Electronique/ESP/ESP.kicad_pcb

Board: 2 copper layers, 12 parts (0 on the bottom side), 13 nets.

Parts:
D1: D; D_5W_P12.70mm_Horizontal
F1: FUSE; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
JP1: JUMPER; Pin_Header_Straight_1x02_Pitch2.54mm
P1: CONN_02X04; Pin_Header_Straight_2x04_Pitch2.54mm
P2: CONN_01X05; Pin_Header_Angled_1x05_Pitch2.54mm
P3, P4: CONN_01X01; MountingHole_3.2mm_M3_DIN965_Pad
R1, R2: 1kR; R_Axial_DIN0207_L6.3mm_D2.5mm_P15.24mm_Horizontal
U1, U3: B_Plug_5mm; B plug 5mm
U2: DSN2596

Connections:
+3V3: P1.2, P2.2, R2.2
GND: P1.7, P2.1, P3.1, P4.1, R1.2
NRST: P1.4, P2.5
unnamed: D1.1, F1.2, U2.1
unnamed: D1.2, U1.2, U2.2
unnamed: F1.1, U1.1
unnamed: JP1.1, P1.3
unnamed: JP1.2, R1.1
unnamed: P1.6, R2.1
unnamed: U2.3, U3.2
unnamed: U2.4, U3.1
RX: P1.1, P2.3
TX: P1.8, P2.4

## Code that names these connections

File Electronique/moteurs_brushless_elec/prop.ioc (part):

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Mcu.Name=STM32F303K(6-8)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32F303K8Tx
PA0.Signal=S_TIM2_CH1_ETR
PA1.Signal=S_TIM2_CH2
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=TACHO_1
PA10.Signal=GPIO_Input
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=LED
PA11.Signal=GPIO_Output
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=TACHO_2
PA12.Signal=GPIO_Input
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=DIAG_2
PA15.Signal=GPIO_Input
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=EN_1
PA6.Signal=S_TIM16_CH1
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=BRAKE_1
PA7.Signal=S_TIM3_CH2
PA8.Signal=S_TIM1_CH1
PA9.Signal=S_TIM1_CH2
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=DIR_1
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=DIAG_1
PB1.Signal=GPIO_Input
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=DIR_2
PB3.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=BRAKE_2
PB4.Signal=S_TIM3_CH1
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=EN_2
PB5.Signal=S_TIM17_CH1
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=64000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK

File Programmation/Central/Central/Central.ioc (part):

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Mcu.Name=STM32F401R(D-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F401RETx
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=RASPBERRY_RX [USART1_RX]
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=PINCE_TX [USART6_TX]
PA11.Mode=Asynchronous
PA11.Signal=USART6_TX
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=PINCE_RX [USART6_RX]
PA12.Mode=Asynchronous
PA12.Signal=USART6_RX
PA13.GPIOParameters=GPIO_Label
PA13.GPIO_Label=TMS
PA13.Signal=SYS_JTMS-SWDIO
PA14.GPIOParameters=GPIO_Label
PA14.GPIO_Label=TCK
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=POSITION_TX [USART2_TX]
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=POSITION_RX [USART2_RX]
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA5.GPIOParameters=GPIO_Speed,GPIO_PuPd,GPIO_Label,GPIO_Mode
PA5.GPIO_Label=LD2 [Green Led]
PA5.GPIO_Mode=GPIO_MODE_OUTPUT_PP
PA5.GPIO_PuPd=GPIO_NOPULL
PA5.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=LED_GREEN
PA6.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=LED_RED
PA7.Signal=GPIO_Output
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=I2C_TOF_SCL [I2C3_SCL]
PA8.Mode=I2C
PA8.Signal=I2C3_SCL
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=RASPBERRY_TX [USART1_TX]
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB10.GPIOParameters=GPIO_Label
PB10.GPIO_Label=I2C_TOF_EN
PB10.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=SWO
PB3.Signal=SYS_JTDO-SWO
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=I2C_TOF_SDA [I2C3_SDA]
PB4.Mode=I2C
PB4.Signal=I2C3_SDA
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PC11.GPIOParameters=GPIO_Label
PC11.GPIO_Label=TOF_RL_RESET
PC11.Signal=GPIO_Output
PC13-ANTI_TAMP.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PC13-ANTI_TAMP.GPIO_Label=B1 [Blue PushButton]
PC13-ANTI_TAMP.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PC13-ANTI_TAMP.GPIO_PuPd=GPIO_NOPULL
PC13-ANTI_TAMP.Signal=GPXTI13
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PC3.GPIOParameters=GPIO_Label
PC3.GPIO_Label=TOF_FL_RESET
PC3.Signal=GPIO_Output
PC3.Stacked=true
PC4.GPIOParameters=GPIO_Label
PC4.GPIO_Label=TOF_FR_RESET
PC4.Signal=GPIO_Output
PC5.GPIOParameters=GPIO_PuPd,GPIO_Label
PC5.GPIO_Label=JACK_START
PC5.GPIO_PuPd=GPIO_PULLUP
PC5.Signal=GPIO_Input
PC6.GPIOParameters=GPIO_PuPd,GPIO_Label
PC6.GPIO_Label=SELEC
PC6.GPIO_PuPd=GPIO_PULLUP
PC6.Signal=GPIO_Input
PC9.GPIOParameters=GPIO_Label
PC9.GPIO_Label=TOF_RR_RESET
PC9.Signal=GPIO_Output
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=84000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=NUCLEO-F401RE
boardIOC=true

File Electronique/driver_moteurs/axe_z.ioc (part):

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Mcu.Name=STM32F303K(6-8)Tx
Mcu.Package=LQFP32
Mcu.UserName=STM32F303K8Tx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=Encodeur_Ch-A
PA0.Signal=S_TIM2_CH1_ETR
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=Encodeur_Ch-B
PA1.Signal=S_TIM2_CH2
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=RX_Servo
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=IN1
PA11.Signal=S_TIM1_CH4
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=IN2
PA12.Signal=S_TIM16_CH1
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=LED
PA15.Signal=GPIO_Output
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=INV
PA4.Signal=GPIO_Output
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=EN
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=FB
PA6.Mode=IN3-Single-Ended
PA6.Signal=ADC2_IN3
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=NSF
PA7.Signal=GPIO_Input
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=EN_Servo
PA8.Signal=GPIO_Output
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=TX_Servo
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=D1
PB0.Signal=S_TIM3_CH3
PB1.GPIOParameters=GPIO_Label
PB1.GPIO_Label=ND2
PB1.Signal=S_TIM3_CH4
PB3.GPIOParameters=GPIO_PuPd,GPIO_Label
PB3.GPIO_Label=FC
PB3.GPIO_PuPd=GPIO_PULLDOWN
PB3.Signal=GPIO_Input
PB6.Mode=I2C
PB6.Signal=I2C1_SCL
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
RCC.HSEPLLFreq_Value=8000000
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=64000000
RCC.SYSCLKSourceVirtual=RCC_SYSCLKSOURCE_PLLCLK

File Programmation/Cetral_Debug/f4/uart-f4/uart-f4.ioc (part):

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Mcu.Name=STM32F401R(D-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32F401RETx
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=RASP_RX
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=PINCE_TX
PA11.Mode=Asynchronous
PA11.Signal=USART6_TX
PA12.GPIOParameters=GPIO_Label
PA12.GPIO_Label=PINCE_RX
PA12.Mode=Asynchronous
PA12.Signal=USART6_RX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA2.GPIOParameters=GPIO_Speed,GPIO_PuPd,GPIO_Label,GPIO_Mode
PA2.GPIO_Label=POSITION_TX
PA2.GPIO_Mode=GPIO_MODE_AF_PP
PA2.GPIO_PuPd=GPIO_PULLUP
PA2.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Speed,GPIO_PuPd,GPIO_Label,GPIO_Mode
PA3.GPIO_Label=POSITION_RX
PA3.GPIO_Mode=GPIO_MODE_AF_PP
PA3.GPIO_PuPd=GPIO_PULLUP
PA3.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA5.GPIOParameters=GPIO_Speed,PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP,GPIO_Mode
PA5.GPIO_Label=LD2
PA5.GPIO_Mode=GPIO_MODE_OUTPUT_PP
PA5.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_PP
PA5.GPIO_PuPd=GPIO_NOPULL
PA5.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PA5.PinState=GPIO_PIN_RESET
PA5.Signal=GPIO_Output
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=RASP_TX
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB3.Signal=SYS_JTDO-SWO
PC13-ANTI_TAMP.GPIOParameters=GPIO_PuPd,GPIO_ModeDefaultEXTI
PC13-ANTI_TAMP.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING
PC13-ANTI_TAMP.GPIO_PuPd=GPIO_NOPULL
PC13-ANTI_TAMP.Signal=GPXTI13
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
PH0\ -\ OSC_IN.Mode=HSE-External-Clock-Source
PH0\ -\ OSC_IN.Signal=RCC_OSC_IN
PH1\ -\ OSC_OUT.Mode=HSE-External-Clock-Source
PH1\ -\ OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=84000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=NUCLEO-F401RE
boardIOC=true

## Commit log (part)

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2017-12-19 correction
2017-12-21 Début lib AX
2017-12-23 modif moteur axe z
2017-12-24 Checksum
2017-12-24 FSM AX_12A
2017-12-24 Extract status packet
2017-12-24 Receive packet
2017-12-24 Send packet
2017-12-24 Debug checksum
2017-12-24 Réception et envoi ok
2017-12-24 correction commentaire
2017-12-24 AX fields
2017-12-24 Field length
2017-12-24 Error handling
2017-12-24 Instructions
2017-12-24 Clean
2017-12-24 Write instruction
2017-12-24 EEPROM
2017-12-24 RAM control
2017-12-24 Debug speed/position
2017-12-24 La lib de noël
2017-12-25 Ajout test
2017-12-25 Lib AX-12A terminée
2017-12-26 axe z routage en cours
2017-12-27 Essai socket TCP
2017-12-27 Schéma upload ESP01
2017-12-27 Schéma ESP01_Upload pdf
2017-12-27 Serveur TCP ESP
2017-12-27 Debug serveur
2017-12-27 Initialisation client
2017-12-27 Ajout SIGTERM
2017-12-27 Client terminé
2017-12-28 Client API
2017-12-28 Client/serveur fonctionnel
2017-12-28 Ajout ID robots + corretion fuite mémoire
2017-12-28 Test
2017-12-28 Sprites
2017-12-28 Fichier inutile
2017-12-28 pseudocode matrice
2017-12-28 Routage driver moteurs
2017-12-28 Correction B.Cu
2017-12-29 Routage brushless
2017-12-30 Modif pince passage courroi
2017-12-31 fichier config f3
2018-01-01 Correction PCB driver moteurs
2018-01-01 Correction schéma driver
2018-01-01 Putsch
2018-01-01 Placement brushless
2018-01-02 Textes PCB
2018-01-02 GND driver moteur
2018-01-02 +3.3 STM32 brushless
2018-01-02 Noms connecteurs brushless
2018-01-02 Label st-link brushless
2018-01-04 License
2018-01-05 ecritures
2018-01-05 gerber
2018-01-12 plexi boitier panneau
2018-01-12 modif pour la commande
2018-01-13 abeille
2018-01-13 bras
2018-01-14 support balise
2018-01-14 mise en plan plexi
2018-01-15 svg plexis separes
2018-01-15 svg plexis decoupe
2018-01-19 ajout flash_file
2018-01-19 modification Readme
2018-01-20 code pour test de flashage
2018-01-21 valeurs de resistance manquantes
2018-01-22 tolerances impression
2018-01-27 carte communications et autres
2018-01-29 ajout valeurs
2018-01-30 blink brushless
2018-01-30 backup option
2018-01-31 abandon PID CMSIS
2018-01-31 PID home made
2018-01-31 PWM correction
2018-01-31 motor control
2018-02-03 led!
2018-02-04 go routage
2018-02-04 lecture netliste
2018-02-05 hacheurs moteurs
2018-02-05 hacheurs brushless
2018-02-05 pdf export
2018-02-06 Routage PCB central
2018-02-07 pdf export and corrections
2018-02-09 Encoder
2018-02-09 Up encoder
2018-02-09 pb graduation pwm
2018-02-09 clk source gne
2018-02-09 margins
2018-02-09 interruption ok
2018-02-09 Encoder test
2018-02-09 Fix encoder dir
2018-02-09 cnt ok
2018-02-11 encoder pid and odometry
2018-02-12 PCB Central
2018-02-12 Jacky LED
2018-02-12 JackyLED Factory
2018-02-12 pcb modif
2018-02-12 modif bouclages
2018-02-12 modifs correcteurs
2018-02-12 code servos
2018-02-13 Update jacky
2018-02-14 trucs qui trainent
2018-02-14 Config matrice
2018-02-14 support capteurs
2018-02-14 Scoreboard : display code
2018-02-15 Correction bug
2018-02-15 Mise à jour serveur
2018-02-15 Mise à jour binaire pixelbot
2018-02-19 motif pour camera
2018-02-20 Protocol
2018-02-20 Jacky LED rpi3 port
2018-02-21 Protocol v1
2018-02-21 Rename
2018-02-22 Makefile : ajout de configure.py
2018-02-23 code test formes
2018-02-25 squarres recognized but problem if several detection
2018-02-25 orientation control and functions
2018-02-25 several colors
2018-02-25 print result
2018-02-26 sofware problem
2018-02-26 all colors and config file
2018-02-26 ready!
2018-02-26 add print
2018-02-27 Test UART
2018-02-27 Réglage encodeurs
    * Ajout d'un test visuel
    * Le compteur a un overflow au bout d'un tour complet
    * Le compteur des deux roues compte dans le sens de marche
2018-02-28 cut for printer
2018-03-01 Mise à jour serveur panneau
2018-03-01 Mise à jour de l'API du panneau
    * La variable score est désormais entièrement gérée par l'API
2018-03-01 Mise à jour matrice
2018-03-01 Mise à jour JackyLED RPI
2018-03-01 encoder pb solved
2018-03-02 Odométrie
2018-03-03 led blink
2018-03-03 Le weak, c'est bien
2018-03-03 Test rp
2018-03-04 Protocole UART
    * Ajout de RP_Process_Data
    * Modification de FSM_GET_BYTE : l'overflow n'est plus pris en charge,
    mais doit être géré à travers RP_Process_Data
2018-03-04 i2c converter reference
2018-03-04 UART-F4
2018-03-04 Mise à jour RPV1
    * Les fonctions de rappel:
    - RP_Packet_Received
    - RP_Error_Handler
    Prennent maintenant l'interface en paramètres.
    * Ces mêmes fonctions sont désormais définies par défaut et sont donc désormais optionnelles.
2018-03-04 Remote Call Server
2018-03-04 Exemple Serveur
2018-03-07 Position : motor.h
2018-03-07 TIM15 Handler : main.c -> stm32f3xx_it.c
2018-03-07 Position : réorganisation code
2018-03-08 Position : encoder test
2018-03-08 Protocol : stm32 macro
2018-03-08 RpV1 : init STM32
2018-03-08 Exemple protocole
2018-03-08 Correction rpv1
2018-03-08 Protocole prêt
    -> Ajout d'une fonction de synchronisation
    -> Ajout d'un code d'exemple pour raspberry
    -> Amélioration du code pour F4
2018-03-09 Schéma ESP_01
    Ajout d'une résistance pour éviter de cramer GPIO0.
2018-03-09 Schéma ESP_01
    Instructions pour le mode programmation.
2018-03-09 Serveur ESP
    -> Ajout du protocole robotronik
2018-03-09 Client-api : correction sur la portée des variables
2018-03-10 RC Server : pack vars
2018-03-10 RC Server: packing and unpacking done
2018-03-10 Test RC_Call
2018-03-10 UART : licence + header
2018-03-13 Code matrice
2018-03-14 Matrices : F3
2018-03-14 Mise à jour pixelbot
    * Séparation déclarations/définitions en .h/.c
    * Correction d'un bug sur les rotations/transpositions
2018-03-14 Mise à jour des sprites du panneau
    * Les sprites sont maintenant exportées dans la bonne direction.
    * Parce qu'elles l'étaient pas.
    * Du coup le code faisait mal aux yeux.
    * Mais genre vraiment.
    * En plus c'est pas optimisé.
2018-03-14 Amélioration code matrices F3
    * Les sprites sont directement lues dans le bon sens
    * Le chargement d'une ligne est fait avant réactualisation (optimise légèrement la durée d'activation des leds, donc la luminosité)
    * L'écriture d'une ligne n'utilise que des opérations binaires, hors appels HAL (réduit le temps d'écriture, donc le temps de désactivaation des leds, donc la luminosité).
2018-03-14 Debug pointeurs
2018-03-14 Augmentation période matrice
2018-03-15 Correction chargement sprite
2018-03-15 Amélioration client matrice
    * Ajout d'un mode log plus détaillé
    * Prise en charge des signaux SIGTERM, SIGINT plus propre
    * Amélioration des accès à la mémoire partagée
    * Ajout d'un timeout pour renvoyer périodiquement le score
2018-03-15 Client : délai avant reconnexion
2018-03-15 Clean client
2018-03-15 Update serveur
2018-03-16 z motor ok
2018-03-18 macro for motor control
2018-03-18 encoder and FC initialisation
2018-03-18 forget the poling timer
2018-03-19 z asser test ok
2018-03-19 test servo ok
2018-03-19 angles correction
2018-03-19 Robotronik Protocol : Init F3 & F4
2018-03-20 Robotronik protocol : added optional ID
2018-03-20 Remote call : added server ID
2018-03-20 Fixed bug on remote_call
2018-03-20 Point de détail
2018-03-20 uart connexions
2018-03-20 Debug central
2018-03-21 Correction matrice
2018-03-21 Amélioration sprites (pour les rageux)
2018-03-21 Score initial
2018-03-21 UrageART
2018-03-21 Fix UART Axe_Z
2018-03-21 server config
2018-03-21 wrong prototype
2018-03-22 ToF include API
2018-03-22 Tof : detection, set addr & init
2018-03-22 ToF : config
2018-03-22 ToF : test
2018-03-22 calibration ok
2018-03-22 the last one I hope
2018-03-22 .img modification solution
2018-03-23 Raspberry : logger & open uart
2018-03-23 Protocol : màj pour unifier les fonctions d'envoi
2018-03-23 Raspberry : boucle uart
2018-03-23 SC_Stop debug
2018-03-23 Code rasbperry : ajout de la matrice
2018-03-25 Player : lecture de répertoire
2018-03-25 Player : Fixed overflow
2018-03-25 forgot return
2018-03-25 Raspberry : camera socket & leds
2018-03-25 Raspberry : communication C -> Py ok
2018-03-26 Code Raspberry
2018-03-26 for connexions
2018-03-26 Raspberry up
2018-03-27 RP_Sync rpi
2018-03-27 raspberry : uart
2018-03-27 RobotrOvision
2018-03-27 Test segfault
2018-03-27 Raspberry : better logs
2018-03-27 Central : config cubemx
2018-03-27 Central : DMA -> LL
2018-03-27 Match start & stop
2018-03-27 Central mxproject
2018-03-29 Raspberry : camera handling and sigterm
2018-03-29 Raspberry : Logger improvements + log raw
2018-03-29 Central : remote stop
2018-03-29 Raspberry : remote stop nucleo
2018-03-29 schéma ok
2018-03-29 schéma ajout découplage
2018-03-29 ready to route
2018-03-29 RagePCB
2018-03-29 smd resistor
2018-03-29 Central : placement
2018-03-30 Central routage
2018-03-30 Central : remote stop + err + logs
2018-03-30 Raspberry up
    + Fix logs
    + Fix camera
    + send asser
    + sigint nucleo
    + blink end
2018-04-02 makefile -j5
2018-04-02 servitude in interruptions
2018-04-02 functions def
2018-04-02 Correction UART Axe Z
2018-04-02 reached function
2018-04-02 AX 12 fonctions
2018-04-02 make file axe Z
2018-04-02 Raspberry asser
2018-04-02 standard functions
2018-04-02 presence function
2018-04-02 all functions registered
2018-04-02 fsm begenning
2018-04-02 Axe Z : watchdog
2018-04-02 AX pb
2018-04-02 Watchdog callback
2018-04-02 Fix include
2018-04-02 fsm completion
2018-04-02 fsm stack ok without special cases
2018-04-03 Up Z Axis
2018-04-03 fsm start
2018-04-04 DStar_Lite display
2018-04-04 DStar : cube osbstacles
2018-04-04 fsm stack ok
2018-04-04 fsm Z ok
2018-04-04 Makefile
2018-04-06 adjustements
2018-04-06 UART server configured
2018-04-06 first functions resgistered
2018-04-06 AStar
2018-04-06 AStar config
2018-04-08 Strat : obstacles
2018-04-08 Plan fsm
2018-04-09 setup ok
2018-04-09 angle generator ok
2018-04-09 Strategy : added stack
2018-04-09 linear generator ok
2018-04-09 sources for curves
2018-04-10 Strategy : set pattern eval
2018-04-10 Central clean
2018-04-10 Strategy : find cubes to make pattern
2018-04-10 Strategy : best set selection
2018-04-11 Central : tof test
2018-04-11 Central : ToF
2018-04-11 Central : clean
2018-04-11 Central : removed cubemx backup
2018-04-11 Added licence for ToF code
2018-04-11 moved release note for VL53L0X API
2018-04-11 license update
2018-04-11 comment fixed
2018-04-12 Strategy update
2018-04-12 rm license
2018-04-12 TOF'
2018-04-12 ToF Ok
2018-04-12 servo ar ok
2018-04-12 Team select
2018-04-14 Bruteforce
2018-04-14 Brute force : verify permutation
2018-04-14 interplation beginning
2018-04-14 Refactoring strat
2018-04-14 complexity incomming
2018-04-14 little correction
2018-04-14 ready for stm32
2018-04-15 just add the link to the pid
2018-04-15 Curves for position
2018-04-15 Bruteforce ok
2018-04-16 little server correction
2018-04-23 Why? :(
2018-04-23 Because Shannon and Nyquist
2018-04-23 Right correction
2018-04-23 2nd Right correction
2018-04-23 dimension modif
2018-04-24 encoder tested
2018-04-25 Obstacles
2018-04-25 Obstacle : delete unrelevant obstacles
2018-04-25 Materialize obstacle
2018-04-26 Central strat
2018-04-26 PID regle
2018-04-26 rage debug
2018-04-26 debug axe z
2018-04-27 bug solved
2018-04-29 Strat : Go(x,y)
2018-04-30 Stratégie : marges adaptatives
2018-05-01 ramp generator and security
2018-05-01 little modif before changes
2018-05-01 forgot acos
2018-05-01 just to be sure of the stop
2018-05-03 Strat : déplacements
2018-05-03 Central pos
2018-05-03 Pos central
2018-05-03 code test
2018-05-03 gnaaaaaaaaaaa
2018-05-03 debug
2018-05-03 asser test
2018-05-05 Central : update obstacles & position & angle
2018-05-05 Central : rotation
2018-05-05 Central : go straight
2018-05-05 Central : avoid robot
2018-05-05 Position : stack path
2018-05-05 Central : gas.c
2018-05-06 initi pos and correct backward bug
2018-05-07 XL-320 : précision
2018-05-07 int to float
2018-05-08 Fix Z server
2018-05-08 Update RC_Call
2018-05-08 Central : build
2018-05-08 Fix raspberry
2018-05-09 Réglage constantes
2018-05-09 Code strat -> simulation
2018-05-09 Raspberry : disable send asser'
2018-05-09 Rage central
2018-05-09 Axe Z
2018-05-09 Tentative d'homologation #échec
2018-05-09 Correction de cette putain de tirette de ses morts, cordialement
2018-05-09 Le clean de ses morts
2018-05-09 Interruption TIM3
2018-05-10 Position central
2018-06-05 cdfr
