# Repository robotronik/cdfr2018

## KiCad design Electronique/Central/central.kicad_pcb

Parts:
D3: LED_Red; LED_D5.0mm
D4: LED_Green; LED_D5.0mm
P1, P6, P7, P8: CONN_02X03; Molex_KK-6410-06_06x2.54mm_Straight
P9: CONN_jack_start; Molex_KK-6410-02_02x2.54mm_Straight
P10: CONN_Selec; Molex_KK-6410-02_02x2.54mm_Straight
P12, P13, P14, P15: CONN_01X02; Molex_KK-6410-02_02x2.54mm_Straight
Q2, Q3: Q_NMOS_DGS
R1, R2, R3, R4: 10kR; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6: 500R
R7, R8, R9, R10, R11, R12, R13, R14: 47kR; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: Nucleo-64
U10, U11, U12, U13, U14, U15: trou-d3mm; MountingHole_3.2mm_M3_Pad

Connections:
+2.8V: P1.5, P6.5, P7.5, P8.5, Q2.2, Q3.2, R3.1, R4.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1; also elsewhere on the board
+3V3: R1.1, R2.1, U1.17 (+3V3), U1.32 (+3V3)
+5V: U1.37 (E5V); also elsewhere on the board
/Pince_RX: P12.2, U1.54 (PA12)
/Pince_TX: P12.1, U1.53 (PA11)
/Position_RX: P13.2, U1.61 (PA3)
/Position_TX: P13.1, U1.62 (PA2)
GND: D3.1 (K), D4.1 (K), P1.6, P6.6, P7.6, P8.6, P9.2, P10.2, U1.10 (GND), U1.29 (GND), U1.30 (GND), U1.36 (GND), U1.44 (AGND), U1.50 (GND), U1.75 (GND), U10.1, U11.1, U12.1, U13.1, U14.1, U15.1; also elsewhere on the board
I2C_Free_SCL: P15.1, U1.71 (PB6)
I2C_Free_SDA: P15.2, U1.9 (PB7)
I2C_TOF_SCL: Q2.1, R2.2, U1.68 (PA8)
I2C_TOF_SDA: Q3.1, R1.2, U1.66 (PB4)
unnamed: D3.2 (A), R6.1
unnamed: D4.2 (A), R5.1
unnamed: P1.1, R14.2
unnamed: P1.2, P6.2, P7.2, P8.2, Q2.3, R3.2
unnamed: P1.3, R10.2
unnamed: P1.4, P6.4, P7.4, P8.4, Q3.3, R4.2
unnamed: P6.1, R7.2
unnamed: P6.3, R11.2
unnamed: P7.1, R8.2
unnamed: P7.3, R12.2
unnamed: P8.1, R9.2
unnamed: P8.3, R13.2
unnamed: P9.1, U1.59 (PC8)
unnamed: P10.1, U1.58 (PC6)
unnamed: R5.2, U1.73 (PA6)
unnamed: R6.2, U1.72 (PA7)
RASP_RX: P14.2, U1.63 (PA10)
RASP_TX: P14.1, U1.69 (PA9)

Notes on the sheet:
FIXED!
Use BSS138

Schematic: Power.sch

Parts:
C1, C2: 1uC; C_Rect_L7.0mm_W2.5mm_P5.00mm
C5: 10uC
C7: CP; CP_Radial_D8.0mm_P3.50mm
D1, D2: D; D_SMA_Handsoldering
F1, F2: FUSE; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
P11: CONN_01X02; Molex_KK-6410-02_02x2.54mm_Straight
R15: 3.3kR
R16: 470R
R17: 330R
R18: 270R
U2, U3: LM317_SOT223
U5, U6: B_Plug_5mm; B plug 5mm
U7, U8: DSN2596

Connections:
+2.8V: C2.1, R18.1, U3.2; also elsewhere on the board
+5V: C1.1, C7.1, U3.3, U7.4 (OUT+); also elsewhere on the board
+9V: R16.1, U2.2; also elsewhere on the board
/Power/Rasp_power: C5.1, P11.1, U8.4 (OUT+)
BATT: D1.1 (K), F1.2, U2.3, U7.1 (IN+)
GND: C1.2, C2.2, C5.2, C7.2, D1.2 (A), D2.2 (A), P11.2, R15.2, R17.2, U5.2, U6.2, U7.2 (IN-), U7.3 (OUT-), U8.2 (IN-), U8.3 (OUT-); also elsewhere on the board
unnamed: D2.1 (K), F2.2, U8.1 (IN+)
unnamed: F1.1, U5.1
unnamed: F2.1, U6.1
unnamed: R15.1, R16.2, U2.1
unnamed: R17.1, R18.2, U3.1

Notes on the sheet:
Non polarisé de plus grande valeur possible
FIXED!

Schematic: Audio.sch

Parts:
C3: 1uC
C4: 390nC
C6: C
P2: CONN_Speaker; Molex_KK-6410-02_02x2.54mm_Straight
P3: CONN_jack; Pin_Header_Straight_1x02_Pitch2.54mm
R19, R21: 20kR
R20: 10kR
U4: TDA6205

Connections:
+5V: C6.1, U4.6; also elsewhere on the board
GND: C3.2, C6.2, P3.1, R20.2, U4.1, U4.7; also elsewhere on the board
unnamed: C3.1, U4.2, U4.3
unnamed: C4.1, R19.2
unnamed: C4.2, P3.2
unnamed: P2.1, U4.8
unnamed: P2.2, R21.1, U4.5
unnamed: R19.1, R21.2, U4.4

Notes on the sheet:
LM4991
G=2*R21/R19
FIXED!

Schematic: LED.sch

Parts:
P4: CONN_jacky_led; Molex_KK-6410-02_02x2.54mm_Straight
P5: CONN_LED; Molex_KK-6410-02_02x2.54mm_Straight
Q1: IRF540N; TO-220
U9: MC34152; DIP-8_W7.62mm_LongPads

Connections:
+5V: P5.1; also elsewhere on the board
+9V: U9.6 (Vcc); also elsewhere on the board
GND: P4.2, Q1.3 (S), U9.3 (GND), U9.4 (IN_B); also elsewhere on the board
unnamed: P4.1, U9.2 (IN_A)
unnamed: P5.2, Q1.2 (D)
unnamed: Q1.1 (G), U9.7 (OUT_A)

Notes on the sheet:
Jacky tuning

Board: 2 copper layers, 64 parts (0 on the bottom side), 47 nets, no tracks yet.

## KiCad design Electronique/hacheurs_brushless/hacheurs_brushless.kicad_pcb

Parts:
P1, P2, P3, P4: CONN_01X01; MountingHole_2.7mm_Pad
U1, U2, U5, U6: B_Plug_5mm; B plug 5mm
U3, U4: DSN2596

Connections:
GND: P1.1, P2.1, P3.1, P4.1, U1.2, U2.2, U3.2 (IN-), U3.3 (OUT-), U4.2 (IN-), U4.3 (OUT-), U5.2, U6.2
unnamed: U1.1, U3.1 (IN+)
unnamed: U2.1, U4.1 (IN+)
unnamed: U3.4 (OUT+), U5.1
unnamed: U4.4 (OUT+), U6.1

Board: 2 copper layers, 10 parts (0 on the bottom side), 5 nets.

## KiCad design Electronique/moteurs_brushless_elec/PCB/carte_moteurs.kicad_pcb

Parts:
U7, U8, U10, U11: Trou-3

Connections:
GND: U7.1, U8.1, U10.1, U11.1; also elsewhere on the board

Parts:
C1, C2: C; C_1206_HandSoldering
Cboot1, Cboot2: 220nC; C_1206_HandSoldering
Cen1, Cen2: 5,6nC; C_1206_HandSoldering
Coff1, Coff2: 1nC; C_1206_HandSoldering
Cp1, Cp2: 10nC; C_1206_HandSoldering
Cpul1, Cpul2: 10nC; C_1206_HandSoldering
D1, D2, D3, D4: 1N4148; D_DO-35_SOD27_P10.16mm_Horizontal
K1, K2: Maxon-200142; Molex-52610-1133
R1, R2, R3, R4: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rdd1, Rdd2: 1kR; R_1206_HandSoldering
Ren1, Ren2: 100kR; R_1206_HandSoldering
Roff1, Roff2: 33kR; R_1206_HandSoldering
Rp1, Rp2: 100R; R_1206_HandSoldering
Rpul1, Rpul2: 47kR; R_1206_HandSoldering
Rsense1, Rsense2: 0.03R; R_Bare_Metal_Element_L12.4mm_W4.8mm_P11.40mm
U1, U2: L6235D; SOIC-24W_7.5x15.4mm_Pitch1.27mm

Connections:
+3V3: R1.2, R3.2, Rdd1.2, Rdd2.2; also elsewhere on the board
+5V: K1.11 (V_Hall), K2.11 (V_Hall); also elsewhere on the board
/motor_part/BRAKE_1: U1.14 (BRAKE); also elsewhere on the board
/motor_part/BRAKE_2: U2.14 (BRAKE); also elsewhere on the board
/motor_part/DIAG_1: Cen1.1, Ren1.1, U1.2 (DIAG), U1.12 (EN); also elsewhere on the board
/motor_part/DIAG_2: Cen2.1, Ren2.1, U2.2 (DIAG), U2.12 (EN); also elsewhere on the board
/motor_part/DIR_1: U1.11 (FWD/REV); also elsewhere on the board
/motor_part/DIR_2: U2.11 (FWD/REV); also elsewhere on the board
/motor_part/EN_1: Ren1.2; also elsewhere on the board
/motor_part/EN_2: Ren2.2; also elsewhere on the board
/motor_part/RCOFF1: Coff1.1, Roff1.1, U1.4 (RCOFF)
/motor_part/RCOFF2: Coff2.1, Roff2.1, U2.4 (RCOFF)
/motor_part/RCPULSE1: Cpul1.1, Rpul1.1, U1.9 (RCPULSE)
/motor_part/RCPULSE2: Cpul2.1, Rpul2.1, U2.9 (RCPULSE)
/motor_part/TACHO_1: Rdd1.1, U1.8 (TACHO); also elsewhere on the board
/motor_part/TACHO_2: Rdd2.1, U2.8 (TACHO); also elsewhere on the board
/motor_part/VBOOT1: Cboot1.1, D2.1 (K), U1.15 (VBOOT)
/motor_part/VBOOT2: Cboot2.1, D4.1 (K), U2.15 (VBOOT)
/motor_part/VCP1: Cp1.1, U1.22 (VCP)
/motor_part/VCP2: Cp2.1, U2.22 (VCP)
/motor_part/Vref1: C1.1, R1.1, R2.2, U1.13 (VREF)
/motor_part/Vref2: C2.1, R3.1, R4.2, U2.13 (VREF)
GND: C1.2, C2.2, Cen1.2, Cen2.2, Coff1.2, Coff2.2, Cpul1.2, Cpul2.2, K1.7 (GND), K2.7 (GND), R2.1, R4.1, Roff1.2, Roff2.2, Rpul1.2, Rpul2.2, Rsense1.2, Rsense2.2, U1.6 (GND), U1.7 (GND), U1.18 (GND), U1.19 (GND), U2.6 (GND), U2.7 (GND), U2.18 (GND), U2.19 (GND); also elsewhere on the board
unnamed: Cp1.2, Rp1.1
unnamed: Cp2.2, Rp2.1
unnamed: D1.1 (K), D2.2 (A), Rp1.2
unnamed: D3.1 (K), D4.2 (A), Rp2.2
unnamed: K1.1 (Motor_winding_1), K1.2 (Motor_winding_1), U1.5 (OUT_1)
unnamed: K1.3 (Motor_winding_2), K1.4 (Motor_winding_2), U1.21 (OUT_2)
unnamed: K1.5 (Motor_winding_3), K1.6 (Motor_winding_3), U1.16 (OUT_3)
unnamed: K1.8 (Hall_sensor_2), U1.23 (H2)
unnamed: K1.9 (Hall_sensor_1), U1.1 (H1)
unnamed: K1.10 (Hall_sensor_3), U1.24 (H3)
unnamed: K2.1 (Motor_winding_1), K2.2 (Motor_winding_1), U2.5 (OUT_1)
unnamed: K2.3 (Motor_winding_2), K2.4 (Motor_winding_2), U2.21 (OUT_2)
unnamed: K2.5 (Motor_winding_3), K2.6 (Motor_winding_3), U2.16 (OUT_3)
unnamed: K2.8 (Hall_sensor_2), U2.23 (H2)
unnamed: K2.9 (Hall_sensor_1), U2.1 (H1)
unnamed: K2.10 (Hall_sensor_3), U2.24 (H3)
unnamed: Rsense1.1, U1.3 (SENSE_A), U1.10 (SENSE_B)
unnamed: Rsense2.1, U2.3 (SENSE_A), U2.10 (SENSE_B)
VCC: Cboot1.2, D1.2 (A), U1.17 (VS_B), U1.20 (VS_A); also elsewhere on the board
VDD: Cboot2.2, D3.2 (A), U2.17 (VS_B), U2.20 (VS_A); also elsewhere on the board

Notes on the sheet:
régler vref et rsense

Parts:
C5: 100nC; C_1206_HandSoldering
D5: LED_ALT; D_SMA-SMB_Universal_Handsoldering
J1: CONN_SERIAL; Molex_KK-6410-02_02x2.54mm_Straight
J2: swdio; Pin_Header_Angled_1x04_Pitch2.54mm
JP1: Jumper_NC_Dual; Pin_Header_Straight_1x03_Pitch2.54mm
P1: CONN_I2C; Molex_KK-6410-02_02x2.54mm_Straight
P2: CONN_FREE; Molex_KK-6410-02_02x2.54mm_Straight
P3: CONN_CAN; Molex_KK-6410-02_02x2.54mm_Straight
R5: 10kR; R_1206_HandSoldering
R6: 470R; R_1206_HandSoldering
R15: R; R_1206_HandSoldering
U3: stm32f303k8t6; LQFP-32_7x7mm_Pitch0.8mm
U9: MCP2562; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+3V3: JP1.3, U3.1 (VDD), U3.5 (VDDA), U3.17 (VDDIO-2), U9.5 (VIO); also elsewhere on the board
+5V: U9.3 (VDD); also elsewhere on the board
/encodeurs/Ch_A1: U3.6 (PA0); also elsewhere on the board
/encodeurs/Ch_A2: U3.18 (PA8); also elsewhere on the board
/encodeurs/Ch_B1: U3.7 (PA1); also elsewhere on the board
/encodeurs/Ch_B2: U3.19 (PA9); also elsewhere on the board
/motor_part/BRAKE_1: U3.13 (PA7); also elsewhere on the board
/motor_part/BRAKE_2: U3.27 (PB4); also elsewhere on the board
/motor_part/DIAG_1: U3.15 (PB1); also elsewhere on the board
/motor_part/DIAG_2: U3.25 (PA15); also elsewhere on the board
/motor_part/DIR_1: U3.14 (PB0); also elsewhere on the board
/motor_part/DIR_2: U3.26 (PB3); also elsewhere on the board
/motor_part/EN_1: U3.12 (PA6); also elsewhere on the board
/motor_part/EN_2: U3.28 (PB5); also elsewhere on the board
/motor_part/TACHO_1: U3.20 (PA10); also elsewhere on the board
/motor_part/TACHO_2: U3.22 (PA12); also elsewhere on the board
/uC/I2C_SCL: P1.2, U3.29 (PB6); also elsewhere on the board
/uC/I2C_SDA: P1.1, U3.30 (PB7); also elsewhere on the board
/uC/RX: J1.1, U3.9 (PA3), U9.4 (RXD); also elsewhere on the board
/uC/TX: J1.2, U3.8 (PA2), U9.1 (TXD); also elsewhere on the board
/uC/nrst: C5.1, J2.2, U3.4 (N-RST); also elsewhere on the board
/uC/swclk: J2.3, U3.24 (PA14); also elsewhere on the board
/uC/swdio: J2.4, U3.23 (PA13); also elsewhere on the board
GND: C5.2, D5.1 (K), J2.1, JP1.1, U3.16 (VSS), U3.32 (VSSA), U9.2 (VSS), U9.8 (STBY); also elsewhere on the board
unnamed: D5.2 (A), R6.2
unnamed: JP1.2, R5.2
unnamed 58: P2.1, U3.11 (PA5); also elsewhere on the board
unnamed 59: P2.2, U3.10 (PA4); also elsewhere on the board
unnamed 60: P3.1, R15.1, U9.7 (CANH); also elsewhere on the board
unnamed 61: P3.2, R15.2, U9.6 (CANL); also elsewhere on the board
unnamed: R5.1, U3.31 (BOOT0/PB8)
unnamed: R6.1, U3.21 (PA11)

Parts:
C6, C10: 100uCP; CP_Radial_D8.0mm_P3.50mm
C7, C11: 100nC; C_1206_HandSoldering
C8, C9: 10uC; CP_Radial_D8.0mm_P3.50mm
D6, D10: D_10A; D_SMA_Handsoldering
D7: LED_VCC; D_SMA-SMB_Universal_Handsoldering
D8: LED_5V; D_SMA-SMB_Universal_Handsoldering
D9: LED_3.3V; D_SMA-SMB_Universal_Handsoldering
D11: LED_ALT; D_SMA-SMB_Universal_Handsoldering
F1, F2: Fuse; Fuseholder5x20_horiz_SemiClosed_Casing10x25mm
J3: FAN; Molex_KK-6410-02_02x2.54mm_Straight
R7, R10, R13, R16: R; R_1206_HandSoldering
R8: 3.3kR; R_1206_HandSoldering
R9: 10kR; R_1206_HandSoldering
R11: 33kR; R_1206_HandSoldering
R12: 56kR; R_1206_HandSoldering
U4, U12: B_Plug_5mm; B plug 5mm
U5, U6: LM317_SOT223; SOT-223-3Lead_TabPin2

Connections:
+3V3: C9.1, R12.1, R13.2, U6.2 (OUT); also elsewhere on the board
+5V: C8.1, R9.1, R10.2, U5.2 (OUT); also elsewhere on the board
GND: C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, D6.2 (A), D7.1 (K), D8.1 (K), D9.1 (K), D10.2 (A), D11.1 (K), J3.2, R8.2, R11.1, U4.2, U12.2; also elsewhere on the board
unnamed: D7.2 (A), R7.1
unnamed: D8.2 (A), R10.1
unnamed: D9.2 (A), R13.1
unnamed: D11.2 (A), R16.1
unnamed: F1.2, U4.1
unnamed: F2.2, U12.1
unnamed: R8.1, R9.2, U5.1 (ADJ)
unnamed: R11.2, R12.2, U6.1 (ADJ)
VCC: C6.1, C7.1, D6.1 (K), F1.1, R7.2, U5.3 (IN), U6.3 (IN); also elsewhere on the board
VDD: C10.1, C11.1, D10.1 (K), F2.1, J3.1, R16.2; also elsewhere on the board
